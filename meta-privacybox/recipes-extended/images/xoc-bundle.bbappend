# Override bundle to use core-image-minimal instead of core-image-base
RAUC_SLOT_rootfs = "core-image-minimal"

